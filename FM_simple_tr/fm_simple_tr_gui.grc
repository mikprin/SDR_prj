options:
  parameters:
    generate_options: qt_gui
    id: fm_simple_tr_gui
    output_language: python
    title: Fm_test
  states: {}

blocks:
- name: amp_coef
  id: variable_qtgui_range
  parameters:
    label: Multiplyer
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(32e3)
  states: {}
- name: bandwidth_0
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: center_freq_0
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: center_out_freq
  id: variable
  parameters:
    value: 108E6
  states: {}
- name: ch_freq
  id: variable
  parameters:
    value: 101.9e6
  states: {}
- name: ch_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samp_rate_hf
  id: variable
  parameters:
    value: int(640e3)
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '-3e6'
    step: '1'
    stop: 3e6
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 'center_freq_0 - ch_freq '
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters: {}
  states: {state: disabled}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate_hf
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp_coef
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mik/git/SDR_prj/FM_simple_tr/file_example_MP3_700KB.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_hf
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 65e3
    decim: int( samp_rate / ch_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    bw0: 200e3
    freq0: 101e6
    gain0: '30'
    if_gain0: '20'
    sample_rate: samp_rate_hf
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: hackrf
    bb_gain0: '20'
    freq0: center_out_freq
    gain0: '14'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate_hf
    ctrlpanel: 'True'
    fc: 10e3
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: bandwidth_0
    fc: ch_freq
    fftsize: fft_size
    grid: 'True'
    name: '"CH freq"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(576e3)
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '25'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0_0, '0', audio_sink_0_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_vector_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_1, '0', osmosdr_sink_0_0, '0']

metadata:
  file_format: 1
