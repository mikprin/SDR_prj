options:
  parameters:
    generate_options: qt_gui
    id: fm_simple_tr_gui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(640e3)
    tau: '75e-6'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_example_MP3_700KB.mp3
    repeat: 'True'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '0.2'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    bw0: 200e3
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', osmosdr_sink_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
